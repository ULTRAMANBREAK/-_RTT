# Keil uVision project 夹子.uvproj, settings and files
target 夹子 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: 夹子 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\scr\Driver
  group User
    ./: main.c
  group Driver
    ./: naf24l01.c naf24l01.h
